require linux-yocto-intel-x86.inc

KBRANCH_intel-x86  = "standard/x86"
