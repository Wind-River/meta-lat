include bootfs.inc

DESCRIPTION = "Provide a native command will build a small boot image \
which can be used for deployment with OSTree"

inherit native
