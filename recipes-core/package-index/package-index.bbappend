require ${@bb.utils.contains('DISTRO_FEATURES', 'lat', '${BPN}_lat.inc', '', d)}
